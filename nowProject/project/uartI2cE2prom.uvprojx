# Keil uVision project uartI2cE2prom.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: NXP.LPC824_DFP.12.0.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uartI2cE2prom
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\common\chip;..\common\board;..\common\CMSIS;..\common\startup;..\peri_driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group app
    ../application/: main.c
  group common
    ../common/board/: board.c
    ../common/chip/: clock_8xx.c ioswm_8xx.c syscon_8xx.c sysinit_8xx.c
    ../common/startup/: keil_startup_lpc82x.s
  group driver
    ../peri_driver/gpio/: gpio_8xx.c
    ../peri_driver/i2c/: i2c_8xx.c
    ../peri_driver/uart/: ring_buffer.c uart_8xx.c
    ../peri_driver/dma/: dma_8xx.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
